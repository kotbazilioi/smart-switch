<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\test_app_rev0.ewp</path>
  </project>
  <batchBuild />
</workspace>
